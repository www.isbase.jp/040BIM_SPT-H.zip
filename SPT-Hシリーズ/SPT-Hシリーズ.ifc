Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [ReferenceView_V1.2], RevitIdentifiers [ContentGUID: 0bf2b43a-6102-4418-b428-4da8559a771d, VersionGUID: 16c1de8b-3ee2-4a84-bb33-76d312ae2ec1, NumberOfSaves: 9], CoordinateReference [CoordinateBase: 共有座標], ExchangeRequirement [Structural]
File name: SPT-Hシリーズ.ifc
Time: 2025-11-05T18:40:09+09:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.4.30.30 (JPN) - IFC 25.4.30.30

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: プロジェクト情報

# IfcBuilding
Pset_BuildingCommon - Reference: プロジェクト情報; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: プロジェクト情報; IsExternal: no
Pset_BuildingStoreyCommon - Reference: プロジェクト情報; sets with these values: 2

# IfcBuildingStorey: レベル:レベル 1, レベル 1
LongName: レベル 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: レベル 1

# IfcBuildingElementProxy: ISベース_SPT:SPT251H, ISベース_SPT:SPT251H:6944
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - Reference: SPT251H; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: SPT251H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.83574 m2; NetVolume: 0.0279267 m3

# IfcBuildingElementProxy: ISベース_SPT:SPT301H, ISベース_SPT:SPT301H:6957
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SPT301H
Pset_EnvironmentalImpactIndicators - Reference: SPT301H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.03574 m2; NetVolume: 0.029761 m3

# IfcBuildingElementProxy: ISベース_SPT:SPT302H, ISベース_SPT:SPT302H:6958
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SPT302H
Pset_EnvironmentalImpactIndicators - Reference: SPT302H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.06071 m2; NetVolume: 0.0316643 m3

# IfcBuildingElementProxy: ISベース_SPT:SPT303H, ISベース_SPT:SPT303H:7178
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SPT303H
Pset_EnvironmentalImpactIndicators - Reference: SPT303H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.28251 m2; NetVolume: 0.0367299 m3

# IfcBuildingElementProxy: ISベース_SPT:SPT351H, ISベース_SPT:SPT351H:6966
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SPT351H
Pset_EnvironmentalImpactIndicators - Reference: SPT351H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.53179 m2; NetVolume: 0.0386693 m3

# IfcBuildingElementProxy: ISベース_SPT:SPT352H, ISベース_SPT:SPT352H:6967
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SPT352H
Pset_EnvironmentalImpactIndicators - Reference: SPT352H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.68299 m2; NetVolume: 0.0425596 m3

# IfcBuildingElementProxy: ISベース_SPT:SPT401H, ISベース_SPT:SPT401H:6975
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SPT401H
Pset_EnvironmentalImpactIndicators - Reference: SPT401H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.86879 m2; NetVolume: 0.0436573 m3

# IfcBuildingElementProxy: ISベース_SPT:SPT451H, ISベース_SPT:SPT451H:6984
In: レベル 1
Type - Material: <Unnamed>, コンクリート、モルタル
Type - Pset_ManufacturerTypeInformation - Manufacturer: アイエスケー株式会社
Pset_BuildingElementProxyCommon - IsExternal: no; Reference: SPT451H
Pset_EnvironmentalImpactIndicators - Reference: SPT451H
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.42579 m2; NetVolume: 0.0549743 m3
